# Keil uVision project SmartWatch.uvprojx, settings and files
target SmartWatch (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: config;bsp;components\toolchain;components\ble\ble_advertising;components\ble\common;components\ble\device_manager;components\drivers_nrf\common;components\drivers_nrf\delay;components\drivers_nrf\gpiote;components\drivers_nrf\config;components\drivers_nrf\hal;components\drivers_nrf\pstorage;components\drivers_nrf\uart;components\libraries\button;components\libraries\timer;components\libraries\trace;components\libraries\uart;components\libraries\util;components\softdevice\common\softdevice_handler;components\softdevice\s110\headers;components\drivers_nrf\twi_master
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ./: main.c
  group Board Support
    bsp/: bsp.c bsp_btn_ble.c
  group nRF_BLE
    components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    components/ble/ble_advertising/: ble_advertising.c
    components/ble/device_manager/: device_manager_peripheral.c
  group nRF_Drivers
    components/libraries/uart/: app_uart.c
    components/drivers_nrf/delay/: nrf_delay.c
    components/drivers_nrf/common/: nrf_drv_common.c
    components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    components/drivers_nrf/uart/: nrf_drv_uart.c
    components/drivers_nrf/pstorage/: pstorage.c
    ./components/drivers_nrf/twi_master/: nrf_drv_twi.c
  group nRF_Libraries
    components/libraries/button/: app_button.c
    components/libraries/util/: app_error.c nrf_assert.c
    components/libraries/timer/: app_timer.c
    components/libraries/trace/: app_trace.c
    components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    components/softdevice/common/softdevice_handler/: softdevice_handler.c
target flash_s110_nrf51_8.0.0_softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: s110_nrf51_8.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  c include: config;components\toolchain
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.0.1, CMSIS:CORE 4.3.0, Device:Startup 8.2.0, Device:Startup 8.11.1
